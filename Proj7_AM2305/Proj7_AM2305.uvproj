# Keil uVision project Proj7_AM2305.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Proj7_AM2305 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: am2305.c main.c uart.c
